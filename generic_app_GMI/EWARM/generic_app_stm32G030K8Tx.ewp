# IAR project generic_app_stm32G030K8Tx.ewp, settings and files
configuration generic_app_stm32G030K8Tx (ARM, debug)
  General.OGChipSelectEditMenu: STM32G030K8 ST STM32G030K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32G030xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Device/ST/STM32G0xx/Source; ../Drivers/CMSIS/Include; ../FlexMouse; ../FlexMouse/Kernel; ../FlexMouse/Drivers; ../FlexMouse/Memory; ../FlexMouse/Features; ../FlexMouse/Regal; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: generic_app_stm32G030K8Tx.hex
  postbuild: "$EXE_DIR$\post_build_script.bat" "$TOOLKIT_DIR$"  "$TARGET_PATH$"
  ILINK.IlinkOutputFile: generic_app_stm32G030K8Tx.out
  ILINK.IlinkIcfFile: stm32g030xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g030xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_crc.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group FlexMouse/Drivers
    ../FlexMouse/Drivers/: driver_adc1.c driver_adc1.h driver_gpio.c driver_gpio.h driver_pwm_input.c driver_pwm_input.h driver_spi1.c driver_spi1.h driver_usart1.c driver_usart1.h driver_usart2.c driver_usart2.h hardware_config.h module_adc1.c module_adc1.h module_err_logHandle.c module_err_logHandle.h module_flash.c module_gpio.c module_gpio.h module_spi1.c module_spi1.h module_tim1.c module_tim1.h module_usart1.c module_usart1.h module_usart2.c module_usart2.h zz_module_flash.h
  group FlexMouse/Features
    ../FlexMouse/Features/: module_analog_0_10v.c module_analog_0_10v.h module_analog_4_20ma.c module_analog_4_20ma.h module_app.c module_app.h module_digital_inputs.c module_digital_inputs.h module_digital_outputs.c module_digital_outputs.h module_flash_blk_setting.c module_flash_blk_setting.h module_modbus.c module_modbus.h module_modbus_application_map.h module_modbus_drive_map.h module_motor_com.c module_motor_com.h module_motor_demand_multiplexer.c module_motor_demand_multiplexer.h module_Motor_FW_Update.c module_Motor_FW_Update.h module_pwm_input.c module_pwm_input.h
  group FlexMouse/Kernel
    ../FlexMouse/Kernel/: scheduler.c scheduler.h sequential_memory.c sequential_memory.h structured_memory.c structured_memory.h
  group FlexMouse/Memory
    ../FlexMouse/Memory/: ram_buffer.c ram_buffer.h ring_buffer.c ring_buffer.h
  group FlexMouse/Regal
    ../FlexMouse/Regal/: macros.h typedef.h
